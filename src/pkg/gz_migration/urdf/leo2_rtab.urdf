Commit message: traversability plugin stable but migiorabile

File: src/pkg/gz_migration/urdf/leo2_rtab.urdf (robot description, URDF)
Before this commit: robot leo_sim, 22 links, 21 joints
Joints:
- joint rocker_R_joint: mimic joint=rocker_L_joint -> (none)
